options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: MODULADORPWM
    output_language: python
    title: Modulador pwm
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: amplitu de la diente de iserra
    start: '-10'
    step: '0.1'
    stop: '30'
    value: '2'
  states: {}
- name: AC
  id: variable_qtgui_range
  parameters:
    label: Amplitud de las constante
    start: '-2'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: DC
  id: variable_qtgui_range
  parameters:
    label: Nivel de la diente de sierra
    start: '-10'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de portadora
    start: '50000000'
    step: '1000000'
    stop: '1000000000'
    value: '50000000'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia del mensaje
    start: '100'
    step: '10'
    stop: '1000'
    value: '200'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia diente de sierra
    start: '100'
    step: '10'
    stop: '10000'
    value: '2000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: ModulosEfren_Compara_0
  id: ModulosEfren_Compara
  parameters: {}
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: fs
    offset: DC-A/2
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: Fc
    fftsize: '8192'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '4096'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [ModulosEfren_Compara_0, '0', blocks_float_to_complex_0, '0']
- [ModulosEfren_Compara_0, '0', qtgui_freq_sink_x_0, '0']
- [ModulosEfren_Compara_0, '0', qtgui_time_sink_x_0, '1']
- [analog_sig_source_x_0, '0', ModulosEfren_Compara_0, '1']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '2']
- [analog_sig_source_x_0_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle_0, '0', ModulosEfren_Compara_0, '0']

metadata:
  file_format: 1
