options:
  parameters:
    author: Labcom
    generate_options: qt_gui
    id: PruebaAM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: AM
  id: variable_qtgui_range
  parameters:
    label: Amplitus mensaje
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: Ancho Pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de mensaje
    start: '0'
    step: '10'
    stop: '10000'
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de pulsos
    start: '0'
    step: '1'
    stop: '10000'
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: AM
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: modulacion_PAM
  id: modulaciondepulsos
  parameters:
    d: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 50e6
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', modulacion_PAM, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '1']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [modulacion_PAM, '0', blocks_float_to_complex_0, '0']
- [modulacion_PAM, '0', qtgui_freq_sink_x_0, '0']
- [modulacion_PAM, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
